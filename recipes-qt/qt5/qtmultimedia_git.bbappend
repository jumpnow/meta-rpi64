PACKAGECONFIG_remove = "gstreamer"
